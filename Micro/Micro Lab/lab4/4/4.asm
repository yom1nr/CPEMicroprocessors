	LF_SEG EQU P1.4
	RG_SEG EQU P1.5
	PT_SEG EQU P0
	ORG 0000H
	JMP 0100H
	ORG 0100H
	MOV SP,#2FH
	
LOOP: 	MOV R7,#12
	MOV R6,#0
	
inLOOP: MOV A,R6
	MOV DPTR,#X_POS
	MOVC A,@A+DPTR
	MOV C,Acc.0
	MOV LF_SEG, C
	MOV C,Acc.1
	MOV RG_SEG, c
	MOV A,R6
	MOV DPTR,#X_SEG
	MOVC A,@A+DPTR
	CPL A
	MOV PT_SEG,A
	CALL DELAY
	CALL DELAY
	INC R6
	DJNZ R7,inLOOP
	JMP LOOP

X_SEG: DB 04H, 01H, 08H, 08H, 20H, 40H, 40H, 10H, 08H, 08H, 02H, 04H
X_POS: DB 01H, 01H, 01H, 02H, 02H, 02H, 01H, 01H, 01H, 02H, 02H, 02H
		
X_SEG1: DB 04H, 01H, 10H, 40H, 40H, 20H, 02H, 04H
X_POS1: DB 01H, 01H, 01H, 01H, 02H, 02H, 02H, 02H
	
Delay: 	MOV B,#00H
	MOV A,#00H
	
_DLY00: DJNZ Acc,_DLY00
	DJNZ B,_DLY00
	RET
	
	END