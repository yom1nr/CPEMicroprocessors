	ORG	0000
	
	MOV	DPTR,#8000H
	
LOOP_:	MOV	A,#11H
	MOVX	@DPTR,A
	INC	DPTR
	
	MOV	R0,DPL
	CJNE	R0,#0FFH,LOOP_
	MOV	R0,DPH
	CJNE	R0,#080H,LOOP_
	
;================================================
	
	MOV	DPTR,#8000H
	MOV	R3,#00H
	MOV	R4,#00H
	MOV	R5,#00H
	MOV	R6,#00H
	MOV	R7,#00H

LOOP:	MOVX	A,@DPTR
	CJNE	A,#00H,NOZERO
	JMP	NEXT_
	
HNIB:	SWAP 	A 
	ANL 	A,#00FH 
	XRL 	A,#001H
	JNZ 	LNIB
	INC	R5
	CJNE	R5,#00H,LNIB
	INC	R4
	CJNE	R4,#00H,LNIB
	INC	R3
	
LNIB: 	MOVX	A,@DPTR
	ANL 	A,#00FH 
	XRL 	A,#001H
	JNZ 	NEXT_
	INC	R5
	CJNE	R5,#00H,NEXT_
	INC	R4
	CJNE	R4,#00H,NEXT_
	INC	R3
	
NEXT_:	INC	DPTR
	MOV	R0,DPL
	CJNE	R0,#000H,LOOP
	MOV	R0,DPH
	CJNE	R0,#082H,LOOP
	
	SJMP	$
	
NOZERO:	INC	R7
	CJNE	R7,#00H,HNIB
	INC	R6
	SJMP	HNIB
		
	END
	