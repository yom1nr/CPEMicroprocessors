	ORG	0000
	
	MOV	DPTR,#8000H
	
LOOP_:	MOV	A,#11H
	MOVX	@DPTR,A
	INC	DPTR
	
	MOV	R0,DPL
	CJNE	R0,#020H,LOOP_
	MOV	R0,DPH
	CJNE	R0,#081H,LOOP_
	
;================================================
	
	MOV	DPTR,#8000H
	MOV	R6,#00H
	MOV	R7,#00H

LOOP:	MOVX	A,@DPTR
	CJNE	A,#00H,NEXT
	
NEXT_:	INC	DPTR
	MOV	R0,DPL
	CJNE	R0,#000H,LOOP
	MOV	R0,DPH
	CJNE	R0,#082H,LOOP
	
	SJMP	$
	
NEXT:	INC	R7
	CJNE	R7,#00H,NEXT_
	INC	R6
	SJMP	NEXT_
		
	END
	