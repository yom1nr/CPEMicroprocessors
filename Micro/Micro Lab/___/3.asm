SW_P10 	EQU 	P1.0
SW_P11 	EQU 	P1.1
SW_P12 	EQU 	P1.2
SW_P13 	EQU 	P1.3

	
	ORG 0000H ; Lab10Srl1.Sub
	JMP 0100H
	ORG 0100H
	MOV SP,#3FH
	CLR EA ; Disable All
	CALL Delay ; Start Delay
	MOV TMOD,#00100001B ; T1M2 T0M1
	MOV SCON,#01010000B ; Serial Mode1
	MOV TH1,#0FBH ; 9600 FBH@18.432MHz
	SETB TR1 ; Start Timer1
	
	MOV 	SP,#2FH
	CLR 	EA
LOOP: 	SETB 	SW_P10
	SETB 	SW_P11
	SETB 	SW_P12
	SETB 	SW_P13
_CHK10: JB 	SW_P10,_CHK11
	MOV A,#'0'
	MOV SBUF,A
	CALL 	DEBOUNCE
	JNB 	SW_P10,$
	CALL 	DEBOUNCE
	JMP 	LOOP

_CHK11: JB 	SW_P11,_CHK12
	MOV A,#'1'
	MOV SBUF,A
	CALL 	DEBOUNCE
	JNB 	SW_P11,$
	CALL 	DEBOUNCE
	JMP 	LOOP
_CHK12: JB 	SW_P12,_CHK13
	MOV A,#'2'
	MOV SBUF,A
	CALL 	DEBOUNCE
	JNB 	SW_P12,$
	CALL 	DEBOUNCE
	JMP 	LOOP
_CHK13: JB SW_P13,_CHKXX
	MOV A,#'3'
	MOV SBUF,A
	CALL 	DEBOUNCE
	JNB 	SW_P13,$
	CALL 	DEBOUNCE
	JMP 	LOOP
_CHKXX: JMP 	LOOP

DEBOUNCE: PUSH 	B
	PUSH 	Acc
	CLR 	A
	MOV 	B,A
	
Delay: CLR A
MOV B,A
Dly00: DJNZ Acc,Dly00
DJNZ B,Dly00
RET
	
END