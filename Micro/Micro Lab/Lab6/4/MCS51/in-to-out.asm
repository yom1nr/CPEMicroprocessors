ORG 	0000H
	JMP 0100H
	ORG 0100H
	MOV SP,#2FH
LOOP: 	CALL LED_B2C
	JMP LOOP
LED_B2C:
	MOV A,#00011000B
	CALL Delay
	MOV A,#00100100B
	CALL Delay
	MOV A,#01000010B
	CALL Delay
	MOV A,#10000001B
	CALL Delay
	
	RET
Delay: 	CPL A
	MOV P2,A
	MOV R0,#5
	MOV B,#200
	MOV A,#200
_DLY00: DJNZ Acc,_DLY00
	DJNZ B,_DLY00
	DJNZ R0,_DLY00
	RET
	END
